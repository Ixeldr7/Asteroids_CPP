# Keil uVision project mbed.uvprojx, settings and files
target NXP LPC4088 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mbed (library)
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: TARGET_LPC4088, TARGET_M4, TARGET_CORTEX_M, TARGET_NXP, TARGET_LPC408X, TOOLCHAIN_ARM_STD, TOOLCHAIN_ARM, __CORTEX_M4, ARM_MATH_CM4, __FPU_PRESENT=1, __MBED__=1, __ASSERT_MSG
  c include: .\api;.\common;.\hal;.\targets\hal\TARGET_NXP\TARGET_LPC408X;.\targets\hal\TARGET_NXP\TARGET_LPC408X\TARGET_LPC4088;.\targets\cmsis;.\targets\cmsis\TARGET_NXP\TARGET_LPC408X;.\targets\cmsis\TARGET_NXP\TARGET_LPC408X\TOOLCHAIN_ARM_STD
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\targets\cmsis\TARGET_NXP\TARGET_LPC408X\TOOLCHAIN_ARM_STD\LPC407X_8X.sct
  group src
    ./common/: assert.c error.c gpio.c lp_ticker_api.c mbed_interface.c pinmap_common.c rtc_time.c semihost_api.c ticker_api.c us_ticker_api.c wait_api.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp board.c retarget.cpp
    ./targets/hal/TARGET_NXP/TARGET_LPC408X/: analogout_api.c gpio_api.c gpio_irq_api.c pinmap.c port_api.c rtc_api.c sleep.c us_ticker.c
    ./targets/hal/TARGET_NXP/TARGET_LPC408X/TARGET_LPC4088/: analogin_api.c can_api.c ethernet_api.c i2c_api.c pwmout_api.c serial_api.c spi_api.c
