# Keil uVision project ebb.uvprojx, settings and files
target NXP LPC4088 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ebb (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: TARGET_LPC4088, TARGET_M4, TARGET_CORTEX_M, TARGET_NXP, TARGET_LPC408X, TOOLCHAIN_ARM_STD, TOOLCHAIN_ARM, __CORTEX_M4, ARM_MATH_CM4, __FPU_PRESENT=1, __MBED__=1, __ASSERT_MSG
  c include: ..\mbed_nxp_lpc408x\api;..\mbed_nxp_lpc408x\common;..\mbed_nxp_lpc408x\hal;..\mbed_nxp_lpc408x\targets\cmsis;..\mbed_nxp_lpc408x\targets\cmsis\TARGET_NXP\TARGET_LPC408X;..\mbed_nxp_lpc408x\targets\cmsis\TARGET_NXP\TARGET_LPC408X\TOOLCHAIN_ARM_STD;..\mbed_nxp_lpc408x\targets\hal\TARGET_NXP\TARGET_LPC408X;..\mbed_nxp_lpc408x\targets\hal\TARGET_NXP\TARGET_LPC408X\TARGET_LPC4088;..\ebb;.\EALib;.\EALib\FATFileSystem;.\EALib\FATFileSystem\ChaN;.\I2S;.\LM75B;.\SDFileSystem
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\mbed_nxp_lpc408x\targets\cmsis\TARGET_NXP\TARGET_LPC408X\TOOLCHAIN_ARM_STD\LPC407X_8X.sct
  group src
    ./: AR1021I2C.cpp EaLcdBoardGPIO.cpp Graphics.cpp WM8731.cpp display.cpp
    ./EALib/: glcdfont.c Adafruit_GFX.cpp AR1021.cpp EaLcdBoard.cpp GFXFb.cpp gpdma.cpp LcdController.cpp MCIFileSystem.cpp MMA7455.cpp QSPIFileSystem.cpp sdram.cpp SPIFI.cpp TSC2046.cpp XBee.cpp
    ./EALib/FATFileSystem/: FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    ./EALib/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp ff.cpp
    ./I2S/: I2S.cpp
    ./LM75B/: LM75B.cpp
    ./SDFileSystem/: SDFileSystem.cpp
